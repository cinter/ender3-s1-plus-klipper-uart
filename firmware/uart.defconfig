## firmware/uart.defconfig
```kconfig
CONFIG_LOW_LEVEL_OPTIONS=y
CONFIG_MACH_STM32=y
CONFIG_MACH_STM32F401=y
CONFIG_STM32_FLASH_START_10000=y
CONFIG_STM32_SERIAL_USART2=y
```
